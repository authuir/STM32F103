# Keil uVision project FreeRTOS.uvproj, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\Libraries\CMSIS\Core\CM3;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\Source\include;..\Libraries\Source\portable\RVDS\ARM_CM3;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\User\inc
  asm include: ..\Libraries\Source\include;..\Libraries\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c USART.c app.c delay.c
  group Lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c
  group CMSIS
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group FreeRTOS
    ../Libraries/Source/: list.c queue.c tasks.c
    ../Libraries/Source/portable/RVDS/ARM_CM3/: port.c
    ../Libraries/Source/portable/MemMang/: heap_2.c
  group USBLib
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Src
    ../User/src/: hw_config.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
target Debug in RAM (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\Libraries\CMSIS\Core\CM3;..\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x20000000 size 0xe000
  memory RVCT9: RAM 0x2000e000 size 0x2000
